;--------------------------------------------------------
; File Created by SDCC : free open source ANSI-C Compiler
; Version 4.0.0 #11528 (Linux)
;--------------------------------------------------------
	.module test
	.optsdcc -mz80
	
;--------------------------------------------------------
; Public variables in this module
;--------------------------------------------------------
	.globl _main
;--------------------------------------------------------
; special function registers
;--------------------------------------------------------
;--------------------------------------------------------
; ram data
;--------------------------------------------------------
	.area _DATA
;--------------------------------------------------------
; ram data
;--------------------------------------------------------
	.area _INITIALIZED
;--------------------------------------------------------
; absolute external ram data
;--------------------------------------------------------
	.area _DABS (ABS)
;--------------------------------------------------------
; global & static initialisations
;--------------------------------------------------------
	.area _HOME
	.area _GSINIT
	.area _GSFINAL
	.area _GSINIT
;--------------------------------------------------------
; Home
;--------------------------------------------------------
	.area _HOME
	.area _HOME
;--------------------------------------------------------
; code
;--------------------------------------------------------
	.area _CODE
;test.c:3: int main()
;	---------------------------------
; Function main
; ---------------------------------
_main::
;test.c:7: for ( a = 0; a < 10; a++ )
	ld	bc, #0x000a
00104$:
	ld	e, c
	ld	d, b
	dec	de
	ld	c, e
	ld	b, d
	ld	a, d
	or	a, e
	jp	NZ, 00104$
;test.c:11: return 0;
	ld	hl, #0x0000
00105$:
;test.c:12: }
	ret
	.area _CODE
	.area _INITIALIZER
	.area _CABS (ABS)
